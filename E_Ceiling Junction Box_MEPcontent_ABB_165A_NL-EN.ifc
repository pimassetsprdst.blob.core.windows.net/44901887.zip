Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2019-02-15T11:04:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 15 11:04:27 2019 * Host: B3ROBRAWR4428 * Database: C:\Users\LFrancu\AppData\Local\Temp\{32177069-D1D8-4D29-9BC3-D382458FD99A}\ifc * Database version: 5507 * Database creation date: Fri Feb 15 11:04:25 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Feb 15 11:04:26 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 15 11:04:26 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcJunctionBox: 165A, E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-EN:165A:33775
In: Level 1
Type - Material: Color RGB 000-076-255
Type - Dimensions - Conduit Diameter: 16 mm; Depth: 58 mm; Length: 70 mm; Rotation U-Axis Correction: 180 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Width: 70 mm
Type - Identity Data - App ID: EL_MODELPARTSYSTEM_MC; Article Description: 55mm 4x16mm low + 4x16mm high ceiling junction box; Article Type: 165A; Base Family Version: 11.25; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: 55mm 4x16mm low + 4x16mm high ceiling junction box; EMCS Version: 4.0; ETIM Article Class: EC002601; Family Version: 11.25; GLN: 8712507100009; GTIN: 8712507001115; Manufacturer: ABB; Manufacturer Art. No.: 7110.410; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=8712507001115&LanguageCode=EN&Country=NL; MEPcontent Class: CEILING_JUNCTION_BOX; Model: 165A; OmniClass Number: 23.80.30.14.24; OmniClass Title: Junction Boxes; Product Line: ABB; Revit Version: 2017; Type Name: 165A; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-EN
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.0439733 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000100752 m3
Identity Data - Function Code: E6000; Mark: 1
Other - Family: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-EN: 165A; Family and Type: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-EN: 165A; Transparency Visible: no; Type: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-EN: 165A; Type Id: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-EN: 165A
Phasing - Phase Created: New Construction
Visibility - CD/RM Cover Visible: no; CD/VK Cover Visible: no
