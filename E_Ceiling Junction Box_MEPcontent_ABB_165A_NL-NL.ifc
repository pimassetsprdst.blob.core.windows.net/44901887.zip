Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-04-02T10:25:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 02 10:25:31 2019 * Host: B3ROBRAWR4428 * Database: C:\Users\LFrancu\AppData\Local\Temp\{F959AE29-509D-4E7B-B4A9-83389B8AEB99}\ifc * Database version: 5507 * Database creation date: Tue Apr 02 10:25:28 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Apr 02 10:25:28 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 02 10:25:28 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcJunctionBox: 165A, E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-NL:165A:1307547
In: V00
Type - Material: Color RGB 000-076-255
Type - Dimensions - Conduit Diameter: 16 mm; Depth: 58 mm; Length: 70 mm; Rotation U-Axis Correction: 180 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Width: 70 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Identity Data - Article Description: Centraaldoos 55 mm 4x16 mm laag + 4x16 mm hoog; Article Type: 165A; Base Family Version: 11.27; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Centraaldoos 55 mm 4x16 mm laag + 4x16 mm hoog; EMCS Version: 4.0; ETIM Article Class: EC002601; Family Version: 11.27; GLN: 8712507100009; GTIN: 8712507001115; Manufacturer: ABB; Manufacturer Art. No.: 7110.410; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=8712507001115&LanguageCode=NL&Country=NL; MEPcontent Class: CEILING_JUNCTION_BOX; Model: 165A; OmniClass Number: 23.80.30.14.24; OmniClass Title: Junction Boxes; Product Line: ABB; Revit Version: 2017; Type Name: 165A; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-NL
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.0439733 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000100752 m3
Identity Data - Design Option: Main Model; Function Code: E6000; Mark: 6
Other - Family: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-NL: 165A; Family and Type: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-NL: 165A; Transparency Visible: no; Type: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-NL: 165A; Type Id: E_Ceiling Junction Box_MEPcontent_ABB_165A_NL-NL: 165A
Phasing - Phase Created: 3. New Construction
Visibility - CD/RM Cover Visible: no; CD/VK Cover Visible: no
